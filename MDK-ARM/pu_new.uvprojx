# Keil uVision project pu_new.uvprojx, settings and files
target pu_new_CM4 (6240000::V6.24::ARMCLANG)
  device: STM32H747IITx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pu_new_CM4 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY, USE_FULL_LL_DRIVER, VERSION=\"2.0.1.1\"
  c misc: -Wno-typedef-redefinition
  c include: ../CM4/Core/Inc;../CM4/Core/Src;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../mx25lm51245g;../util;../pcm1753;../common;../fatfs;../libmad;../softuart;../opus;../opus/include;../opus/celt;../opus/silk;../opus/silk/fixed;../opus/src;../w5500/ioLibrary_driver/Ethernet;../w5500/ioLibrary_driver/Internet/DHCP;../w5500/ioLibrary_driver/Internet/DNS;../w5500/ioLibrary_driver/Internet/httpServer;../w5500/ioLibrary_driver/Application/loopback;../ch378;../bq32000;..\CM7\Core\Inc;../CM7/Core/Inc/Screens;..\Drivers\STM32H7xx_HAL_Driver\Src;..\i2c2;..\ws_rubetec;..\w5500\ioLibrary_Driver\Ethernet\W5500
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  scatter file: stm32h747xx_flash_CM4.sct
  group Application/User/CM7/Core
    ../CM7/Core/Src/: stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
    ../MDK-ARM/: startup_stm32h747xx_CM7.s
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c
  group CM4/Core/Src
    ../CM4/Core/Src/: sysmem.c syscalls.c console.c pd_i2c.c cm4core.c setting.c external_flash.c mki.c mkk.c mup.c uart2.c net.c safety.c rtc.c um.c uart6.c fault.c speaker.c http_server.c main.c
  group Drivers/STM32H7xx_HAL_Driver/Src
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_ll_usb.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_rcc.c
  group Common/Src
    ../Common/Src/: system_stm32h7xx_dualcore_boot_cm4_cm7.c
  group util
    ../util/: ringbuff_util.c stm_util.c timer_util.c logfile_util.c str_util.c dynbuf_util.c fatfs_util.c httpserver_util.c txt_file_util.c http_util.c math_util.c net_util.c utf8_util.c strlist_util.c mp3read_util.c mad_util.c pcm_util.c opus_util.c ogg_util.c oggopus_util.c
  group softuart
    ../softuart/: softuart.c
  group fatfs
    ../fatfs/: ff.c diskio.c ffsystem.c ffunicode.c
  group mx25lm51245g
    ../mx25lm51245g/: mx25lm51245g.c mx25lm51245g_io.c w25qx.c
  group common
    ../Common/: common.c
  group bq32000
    ../bq32000/: bq32000.c
  group ch378
    ../ch378/: ch378.c
  group w5500/ioLibrary_driver/Ethernet
    ../w5500/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c virtual_socket_map.c
    ../w5500/ioLibrary_Driver/Internet/httpServer/: httpParser.c httpServer.c httpUtil.c
  group w5500/ioLibrary_driver/Internet/httpServer/
    ../w5500/ioLibrary_Driver/Internet/DHCP/: dhcp.h
  group w5500/ioLibrary_driver/Ethernet/W5500
    ../w5500/ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group w5500/ioLibrary_driver/Internet/DHCP
    ../w5500/ioLibrary_Driver/Internet/DHCP/: dhcp.c
  group w5500/ioLibrary_driver/Internet/DNS
    ../w5500/ioLibrary_Driver/Internet/DNS/: dns.c
  group w5500/ioLibrary_driver/Application/loopback/
    ../w5500/ioLibrary_Driver/Application/loopback/: loopback.c
  group CM7/Core/Src
    ../CM7/Core/Src/: beep.c cm7core.c display.c main.c mchs_mic.c mp3files.c mux_sound.c opus_buffer.c pd.c playmem.c playmp3.c playopus.c pu.c sendopus.c syscalls.c sysmem.c uarts.c
  group CM7/Core/Src/Screens
    ../CM7/Core/Src/Screens/: screen0.c screen1.c screen2.c screen3.c screen4.c screen5.c screen6.c screen7.c screens.c
  group pcm1753
    ../pcm1753/: pcm1753.c
  group opus/src
    ../opus/src/: opus_decoder.c opus_encoder.c opus.c repacketizer.c
  group libmad/her
    ../libmad/: huffman.c timer.c bit.c frame.c layer3.c layer12.c synth.c stream.c
  group opus/silk
    ../opus/silk/: dec_API.c init_decoder.c CNG.c PLC.c decoder_set_fs.c stereo_decode_pred.c resampler.c decode_indices.c tables_other.c resampler_private_up2_HQ.c decode_pulses.c resampler_rom.c resampler_private_IIR_FIR.c NLSF_unpack.c decode_frame.c A2NLSF.c ana_filt_bank_1.c biquad_alt.c bwexpander.c bwexpander_32.c check_control_input.c code_signs.c control_audio_bandwidth.c control_codec.c control_SNR.c debug.c decode_core.c decode_parameters.c decode_pitch.c enc_API.c encode_indices.c encode_pulses.c gain_quant.c HP_variable_cutoff.c init_encoder.c inner_prod_aligned.c interpolate.c lin2log.c log2lin.c LP_variable_cutoff.c LPC_analysis_filter.c LPC_fit.c LPC_inv_pred_gain.c NLSF_decode.c NLSF_del_dec_quant.c NLSF_encode.c NLSF_stabilize.c NLSF_VQ.c NLSF_VQ_weights_laroia.c NLSF2A.c NSQ.c NSQ_del_dec.c pitch_est_tables.c process_NLSFs.c quant_LTP_gains.c resampler_down2.c resampler_down2_3.c resampler_private_AR2.c resampler_private_down_FIR.c shell_coder.c sigm_Q15.c sort.c stereo_encode_pred.c stereo_find_predictor.c stereo_LR_to_MS.c stereo_MS_to_LR.c stereo_quant_pred.c sum_sqr_shift.c table_LSF_cos.c tables_gain.c tables_LTP.c tables_NLSF_CB_NB_MB.c tables_NLSF_CB_WB.c tables_pitch_lag.c tables_pulses_per_block.c VAD.c VQ_WMat_EC.c
    ../opus/silk/fixed/: encode_frame_FIX.c apply_sine_window_FIX.c autocorr_FIX.c burg_modified_FIX.c corrMatrix_FIX.c find_LPC_FIX.c find_LTP_FIX.c find_pitch_lags_FIX.c find_pred_coefs_FIX.c k2a_FIX.c k2a_Q16_FIX.c LTP_analysis_filter_FIX.c LTP_scale_ctrl_FIX.c noise_shape_analysis_FIX.c pitch_analysis_core_FIX.c process_gains_FIX.c regularize_correlations_FIX.c residual_energy_FIX.c residual_energy16_FIX.c schur_FIX.c schur64_FIX.c vector_ops_FIX.c warped_autocorrelation_FIX.c
  group opus/celt/
    ../opus/celt/: bands.c celt.c celt_decoder.c celt_encoder.c celt_lpc.c cwrs.c entcode.c entdec.c entenc.c kiss_fft.c laplace.c mathops.c mdct.c modes.c opus_custom_demo.c pitch.c quant_bands.c rate.c vq.c
  group Application/User/CM4/Core
    ../CM4/Core/Src/: stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.c
    ../MDK-ARM/: startup_stm32h747xx_CM4.s
  group i2c2
    ../i2c2/: i2c2.c
  group ws_rubetec
    ../ws_rubetec/: context_w5500.c user_timer.c web_socket.c ws_crypto.c ws_rubetec.c ws_server.c
target pu_new_CM7 (6240000::V6.24::ARMCLANG)
  device: STM32H747IITx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x00000000-0xFFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: pu_new_CM7 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CORE_CM7,USE_HAL_DRIVER,STM32H747xx,USE_PWR_LDO_SUPPLY,alloca=__builtin_alloca,HAL_QSPI_MODULE_ENABLED,HAL_SPI_MODULE_ENABLED,VERSION=\"2.0.1.2\"
  c misc: -Wno-typedef-redefinition
  c include: ..\CM4\Core\Src;..\CM7\Core\Src;..\util;..\common;..\fatfs;..\softuart;..\w5500\ioLibrary_Driver\Ethernet;..\w5500\ioLibrary_Driver\Internet\DHCP;..\w5500\ioLibrary_Driver\Internet\DNS;..\w5500\ioLibrary_Driver\Internet\httpServer;..\w5500\ioLibrary_Driver\Application\loopback;..\mx25lm51245g;..\bq32000;..\CM7\Core\Inc;..\CM4\Core\Inc;..\CM7\Core\Inc\Screens;..\pcm1753;..\opus\src;..\opus\silk;..\opus\celt;..\opus\;..\libmad;..\ch378;..\bq32000;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\STM32H7xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\CMSIS\Include;..\opus\include;..\opus\silk\fixed
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: stm32h747xx_flash_CM7.sct
software components: CMSIS:CORE 6.1.0
